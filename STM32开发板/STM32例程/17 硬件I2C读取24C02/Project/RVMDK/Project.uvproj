# Keil uVision project Project.uvproj, settings and files
target HC6800-EM3 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 24CO2 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\;..\..\Libraries\CMSIS\Core\CM3;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: main.c i2c_ee.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
