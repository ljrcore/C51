# Keil uVision project Project.uvproj, settings and files
target HC6800-EM3 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 矩阵键盘 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c
  group FWLib
    C:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
